# Keil uVision project STM32W5500.uvproj, settings and files
target QITAS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: qitas +hex
  AfterMake: fromelf.exe --bin --output ./obj/qitas.bin ./obj/qitas.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\user;.\system;.\Libs\inc;.\Libs\src;.\output;.\user\24c02;.\user\device;.\user\md5;.\user\socket;.\user\spi;.\user\ult;.\user\w5500;.\user\ntp;.\user\usart;.\word;.\MQTT;.\MQTT;.\user\dns
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c stm32f10x_it.c stm32f10x_it.h stm32f10x_conf.h types.h config.h
  group system
    ./system/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Libs
    ./Libs/src/: misc.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group BSP
    ./user/24c02/: 24c16.c 24c16.h
    ./user/device/: device.c device.h
    ./user/md5/: md5.c md5.h
    ./user/socket/: socket.c socket.h
    ./user/spi/: spi2.c spi2.h
    ./user/ult/: ult.c ult.h
    ./user/w5500/: w5500.c w5500.h
    ./user/ntp/: ntp.c ntp.h
    ./user/usart/: usart.c usart.h
    ./user/: sha1.c timer.c msg_command.c
    ./user/dns/: dns.c
  group tcp_client
    ./user/: tcp_client.c
  group mqtt_libs
    ./MQTT/: cJSON.c MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group mqtt_fun
    ./MQTT/: mqtt_fun.c

# Keil uVision project DHCP.uvproj, settings and files
target qitas (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: tcp_server +hex
  AfterMake: fromelf.exe #L --vhx --8x1 --output main.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\Libraries\CMSIS;.\User;.\Libraries\FWlib\inc;.\User\Ethernet\Internet;.\User\Ethernet\W5500;.\User\usart;.\User\led;.\User\I2C_EEPROM;.\User\spi;.\User\TimBase;.\User\NTP;.\User\DNS;.\MQTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h flash.c timer.c ALIYUN.c
    ./User/usart/: bsp_usart1.c bsp_usart1.h
    ./User/led/: bsp_led.c bsp_led.h
    ./User/I2C_EEPROM/: bsp_i2c_ee.c bsp_i2c_ee.h bsp_i2c_gpio.c bsp_i2c_gpio.h
    ./User/NTP/: ntp.c
    ./User/spi/: bsp_spi_flash.c
  group FWLB
    ./Libraries/FWlib/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group W5500
    ./User/Ethernet/W5500/: w5500_conf.c w5500_conf.h w5500.c w5500.h socket.c socket.h utility.c utility.h types.h
  group Internet
    ./User/Ethernet/Internet/: tcp_demo.c tcp_demo.h dhcp.c dhcp.h udp_demo.c udp_demo.h
    ./User/DNS/: dns.c
    ./User/: tcp_client.c
  group STARTUP
    ./Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group MQTT
    ./MQTT/: cJSON.c mqtt.c MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
